Commit message: Fix camera_frame doesn't exist

File: urdf/jaguar.urdf (robot description, URDF)
Before this commit: robot jaguar_robot, 4 links, 3 joints
Joints:
- joint zed2_camera_joint: parent camera_frame -> base_link
